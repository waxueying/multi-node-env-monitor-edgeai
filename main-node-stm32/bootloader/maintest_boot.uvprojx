# Keil uVision project maintest_boot.uvprojx, settings and files
target boot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x800BFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: boot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: __STDC_LIMIT_MACROS, SOC_FAMILY_STM32, USE_HAL_DRIVER, RT_USING_ARMLIBC, SOC_SERIES_STM32F4, STM32F407xx, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC
  c include: rt-thread\components\libc\posix\ipc;rt-thread\libcpu\arm\common;libraries\CMSIS\Include;libraries\STM32F4xx_HAL_Driver\Inc\Legacy;rt-thread\components\libc\posix\io\poll;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;drivers\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\io\eventfd;.;rt-thread\components\net\sal\impl;libraries\STM32F4xx_HAL_Driver\Inc;rt-thread\components\utilities\resource;drivers\include\config;libraries\CMSIS\Device\ST\STM32F4xx\Include;rt-thread\components\libc\posix\io\epoll;drivers\include\config;libraries\STM32F4xx_HAL_Driver\Inc\Legacy;drivers\include;libraries\CMSIS\Include;drivers;packages\at_device-latest\inc;libraries\STM32F4xx_HAL_Driver\Inc;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\net\at\include;rt-thread\components\drivers\include;libraries\STM32F4xx_HAL_Driver\Inc;libraries\CMSIS\Device\ST\STM32F4xx\Include;drivers;libraries\STM32F4xx_HAL_Driver\Inc\Legacy;rt-thread\components\net\sal\include\socket\sys_socket;packages\pahomqtt-latest\MQTTClient-RT;drivers;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\socket;packages\at_device-latest\class\esp8266;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;rt-thread\include;rt-thread\components\finsh;libraries\CMSIS\Include;libraries\CMSIS\Device\ST\STM32F4xx\Include;packages\pahomqtt-latest\MQTTPacket\src;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\net\at\at_socket;applications;rt-thread\libcpu\arm\cortex-m4
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group src
    ./src/: main.c startup_stm32f407xx.s
software components: CMSIS:CORE 4.3.0
