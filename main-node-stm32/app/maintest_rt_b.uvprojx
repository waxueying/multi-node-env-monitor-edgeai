# Keil uVision project maintest_rt_b.uvprojx, settings and files
target maintest_rt_b (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8080000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: maintest_rt_b +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: __STDC_LIMIT_MACROS, SOC_FAMILY_STM32, USE_HAL_DRIVER, RT_USING_ARMLIBC, SOC_SERIES_STM32F4, STM32F407xx, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, VECT_TAB_OFFSET=0x00080000
  c include: rt-thread\components\libc\posix\ipc;rt-thread\libcpu\arm\common;libraries\CMSIS\Include;libraries\STM32F4xx_HAL_Driver\Inc\Legacy;rt-thread\components\libc\posix\io\poll;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;drivers\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\io\eventfd;.;rt-thread\components\net\sal\impl;libraries\STM32F4xx_HAL_Driver\Inc;rt-thread\components\utilities\resource;drivers\include\config;libraries\CMSIS\Device\ST\STM32F4xx\Include;rt-thread\components\libc\posix\io\epoll;drivers\include\config;libraries\STM32F4xx_HAL_Driver\Inc\Legacy;drivers\include;libraries\CMSIS\Include;drivers;packages\at_device-latest\inc;libraries\STM32F4xx_HAL_Driver\Inc;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\net\at\include;rt-thread\components\drivers\include;libraries\STM32F4xx_HAL_Driver\Inc;libraries\CMSIS\Device\ST\STM32F4xx\Include;drivers;libraries\STM32F4xx_HAL_Driver\Inc\Legacy;rt-thread\components\net\sal\include\socket\sys_socket;packages\pahomqtt-latest\MQTTClient-RT;drivers;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\socket;packages\at_device-latest\class\esp8266;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;rt-thread\include;rt-thread\components\finsh;libraries\CMSIS\Include;libraries\CMSIS\Device\ST\STM32F4xx\Include;packages\pahomqtt-latest\MQTTPacket\src;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\net\at\at_socket;applications;rt-thread\libcpu\arm\cortex-m4
  memory RVCT4: ROM 0x8080000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Applications
    applications/: mqtt_client.c sd_storage.c can_receiver.c main.c oled_display.c ota_flag.c ota_flash.c ota_download.c
  group AT
    rt-thread/components/net/at/src/: at_cli.c at_client.c at_utils.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-latest/samples/: at_sample_esp8266.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
  group Drivers
    drivers/: drv_clk.c drv_sdio.c drv_pwm.c OLED_Data.c drv_usart.c drv_spi.c drv_common.c drv_crypto.c drv_usart_v2.c drv_pm.c drv_flash_f4.c drv_lptim.c drv_wdt.c drv_can.c drv_usbh.c board.c drv_eth.c drv_rtc.c drv_dac.c drv_usbd.c drv_lcd.c OLED.c drv_hwtimer.c drv_lcd_mipi.c drv_pulse_encoder.c drv_soft_i2c.c drv_gpio.c drv_adc.c drv_qspi.c drv_sdram.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: cmd.c msh_parse.c msh_file.c shell.c msh.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_eth.c stm32f4xx_hal_hash_ex.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_crc.c stm32f4xx_ll_utils.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_sai.c stm32f4xx_ll_tim.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_ll_i2c.c stm32f4xx_hal_cortex.c stm32f4xx_hal_mmc.c stm32f4xx_ll_rcc.c stm32f4xx_hal_i2c.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_hash.c stm32f4xx_hal_pcd.c stm32f4xx_hal_smbus.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_qspi.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_ll_pwr.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_sai_ex.c stm32f4xx_ll_exti.c stm32f4xx_ll_adc.c stm32f4xx_ll_usb.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_nand.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_sd.c stm32f4xx_hal_sram.c stm32f4xx_hal_dcmi.c stm32f4xx_ll_lptim.c stm32f4xx_hal_dac.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_lptim.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_pccard.c stm32f4xx_hal_spi.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_hal_adc.c stm32f4xx_hal_cryp.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_hal_i2s_ex.c stm32f4xx_ll_dac.c stm32f4xx_hal_can.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rng.c stm32f4xx_ll_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_spdifrx.c stm32f4xx_ll_dma.c stm32f4xx_hal_cec.c stm32f4xx_hal_fmpsmbus_ex.c
    libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group paho-mqtt
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTSerializePublish.c MQTTFormat.c MQTTConnectClient.c MQTTSubscribeServer.c MQTTSubscribeClient.c MQTTDeserializePublish.c MQTTConnectServer.c MQTTUnsubscribeClient.c MQTTPacket.c MQTTUnsubscribeServer.c
    packages/pahomqtt-latest/MQTTClient-RT/: paho_mqtt_pipe.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group Utilities
    rt-thread/components/utilities/resource/: resource_id.c
software components: CMSIS:CORE 4.3.0
